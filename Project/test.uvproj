# Keil uVision project test.uvproj, settings and files
target project (ARM-ADS)
  device: STM32F427VI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: test +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=..\Output\bin\@L.bin !L
  c flags: Optim=1 wLevel=2
  c define: STM32F4XX,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\user;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\basics
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group lib
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_i2c.c stm32f4xx_dma.c stm32f4xx_sdio.c
  group startup
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group user
    ../user/: main.c testcase1.c rgb.c
    ../basics/: stm32f4xx_it.c SysTick.c uart.c exti.c nvic.c i2c.c spi.c mpu6000.c sdio_sdcard.c sd_card.c
